options:
  parameters:
    author: rsummers
    generate_options: qt_gui
    id: fm_demod
    output_language: python
    title: FM Demodulation
  states: {}

blocks:
- name: audio_filter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '15000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '87.9'
    step: '0.2'
    stop: '107.9'
    value: '106.3'
  states: {}
- name: rbds_bpf_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '58.65'
    low_cutoff_freq: '55.35'
    samp_rate: samp_rate
    type: band_pass
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rbds_lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1650'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rbds_samp_per_sym
  id: variable
  parameters:
    value: samp_rate / 1187.5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '228000'
  states: {}
- name: stereo_diff_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: band_pass
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: stereo_pilot_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * 3.141592 * 19200 / samp_rate
    min_freq: 2 * 3.141592 * 18800 / samp_rate
    w: 2 * 3.141592 * 65 / samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: int(samp_rate * 15 / 80)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Creates left channel
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    comment: Create right channel
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: volume / 100 / 3.141592
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: stereo_pilot_filter_taps
    type: fcc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: audio_filter
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: audio_filter
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: stereo_diff_filter_taps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rbds_lpf_taps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rbds_bpf_taps
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_2_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rbds_bpf_taps
    type: fff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '128'
    win: firdes.WIN_HAMMING
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: samp_rate * 10
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(channel_freq * 1e6)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate * 10
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: int(samp_rate * 0.10)
    type: complex
    ymin: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    size: int(samp_rate * 0.10)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Left Channel
    label2: Right Channel
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    interp: '15'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    interp: '15'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: quad
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: stereo_carrier
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: rbds_carrier
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: quad
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: stereo_carrier
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: quad
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rbds_carrier
  states: {}

connections:
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_fm_deemph_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_2, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_add_xx_0_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_imag_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_imag_0_0, '0', virtual_sink_2, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_2, '1']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_1, '0']
- [blocks_multiply_xx_2, '0', blocks_complex_to_imag_0_0, '0']
- [blocks_multiply_xx_3, '0', fir_filter_xxx_1_0_1, '0']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1, '0', blocks_multiply_const_xx_1, '0']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0_0, '1']
- [fir_filter_xxx_1_0_0, '0', blocks_multiply_xx_1, '0']
- [fir_filter_xxx_1_0_1, '0', hilbert_fc_0, '0']
- [fir_filter_xxx_1_0_2, '0', blocks_multiply_xx_3, '0']
- [fir_filter_xxx_1_0_2_0, '0', blocks_multiply_xx_3, '1']
- [hilbert_fc_0, '0', blocks_complex_to_arg_1, '0']
- [hilbert_fc_0, '0', qtgui_const_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '1']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [rational_resampler_xxx_1, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_1_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1, '1']
- [virtual_source_2, '0', fir_filter_xxx_1_0, '0']
- [virtual_source_2, '0', fir_filter_xxx_1_0_2, '0']
- [virtual_source_3, '0', fir_filter_xxx_1_0_2_0, '0']

metadata:
  file_format: 1
