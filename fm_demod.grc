options:
  parameters:
    author: rsummers
    generate_options: qt_gui
    id: fm_demod
    output_language: python
    title: FM Demodulation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rsummers/Documents/gr-examples/data/FM_Radio_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/rsummers/Documents/gr-examples/fm_results
    samp_rate: int(samp_rate / 5)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_arg_0, '0', analog_fm_deemph_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
